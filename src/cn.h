// ============================================================
// cn.h - Internal font (8x16 ASCII + fallback CJK)
// Only test Chinese characters kept
// ============================================================

#ifndef CN_H
#define CN_H

#include "screen.h"
#include "FontManager.h"

// ============================================================
// Chinese char descriptor
// ============================================================
struct ChineseChar {
    const char *code;
    const unsigned char *data;
    uint8_t width;
    uint8_t height;
};

// ============================================================
// Test Chinese chars (16x16)
// ============================================================
static const unsigned char char_你[] = {0x08,0x80,0x08,0x80,0x08,0x80,0x11,0xFE,0x11,0x02,0x32,0x04,0x34,0x20,0x50,0x20,0x91,0x28,0x11,0x24,0x12,0x24,0x12,0x22,0x14,0x22,0x10,0x20,0x10,0xA0,0x10,0x40};
static const unsigned char char_好[] = {0x10,0x00,0x10,0xFC,0x10,0x04,0x10,0x08,0xFC,0x10,0x24,0x20,0x24,0x20,0x25,0xFE,0x24,0x20,0x48,0x20,0x28,0x20,0x10,0x20,0x28,0x20,0x44,0x20,0x84,0xA0,0x00,0x40};
static const unsigned char char_世[] = {0x02,0x20,0x12,0x20,0x12,0x20,0x12,0x20,0x12,0x20,0xFF,0xFE,0x12,0x20,0x12,0x20,0x12,0x20,0x12,0x20,0x13,0xE0,0x10,0x00,0x10,0x00,0x10,0x00,0x1F,0xFC,0x00,0x00};
static const unsigned char char_界[] = {0x00,0x00,0x1F,0xF0,0x11,0x10,0x11,0x10,0x1F,0xF0,0x11,0x10,0x11,0x10,0x1F,0xF0,0x02,0x80,0x0C,0x60,0x34,0x58,0xC4,0x46,0x04,0x40,0x08,0x40,0x08,0x40,0x10,0x40};
static const unsigned char char_中[] = {0x01,0x00,0x01,0x00,0x01,0x00,0x01,0x00,0x3F,0xF8,0x21,0x08,0x21,0x08,0x21,0x08,0x21,0x08,0x21,0x08,0x3F,0xF8,0x21,0x08,0x01,0x00,0x01,0x00,0x01,0x00,0x01,0x00};
static const unsigned char char_文[] = {0x02,0x00,0x01,0x00,0x01,0x00,0xFF,0xFE,0x10,0x10,0x10,0x10,0x08,0x20,0x08,0x20,0x04,0x40,0x02,0x80,0x01,0x00,0x02,0x80,0x04,0x40,0x08,0x20,0x30,0x18,0xC0,0x06};

// ============================================================
// Internal font table
// ============================================================
static const ChineseChar CHINESE_TABLE[] = {
    {"你", char_你, 16, 16},
    {"好", char_好, 16, 16},
    {"世", char_世, 16, 16},
    {"界", char_界, 16, 16},
    {"中", char_中, 16, 16},
    {"文", char_文, 16, 16},
};
#define CHINESE_COUNT (sizeof(CHINESE_TABLE) / sizeof(CHINESE_TABLE[0]))

static const unsigned char font8x16_punct[][16] = {
    // 0: full-width comma
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x10},
    // 1: full-width period
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1C,0x14,0x1C},
    // 2: full-width exclamation
    {0x00,0x00,0x00,0x00,0x18,0x18,0x18,0x18,0x18,0x00,0x00,0x18,0x18,0x00,0x00,0x00},
    // 3: full-width question
    {0x00,0x00,0x00,0x00,0x3C,0x42,0x42,0x06,0x0C,0x18,0x18,0x00,0x18,0x18,0x00,0x00},
    // 4: full-width colon
    {0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00},
    // 5: full-width semicolon
    {0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x18,0x18,0x10,0x20,0x20,0x00},
    // 6: full-width left paren
    {0x00,0x00,0x00,0x0C,0x18,0x30,0x30,0x30,0x30,0x30,0x30,0x18,0x0C,0x00,0x00,0x00},
    // 7: full-width right paren
    {0x00,0x00,0x00,0x30,0x18,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x18,0x30,0x00,0x00,0x00},
    // 8: full-width left bracket
    {0x00,0x00,0x00,0x3C,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x3C,0x00,0x00,0x00},
    // 9: full-width right bracket
    {0x00,0x00,0x00,0x3C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x3C,0x00,0x00,0x00},
    // 10: full-width minus
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    // 11: full-width equal
    {0x00,0x00,0x00,0x00,0x00,0xFE,0x00,0x00,0xFE,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    // 12: full-width less-than
    {0x00,0x00,0x00,0x04,0x08,0x10,0x20,0x40,0x20,0x10,0x08,0x04,0x00,0x00,0x00,0x00},
    // 13: full-width greater-than
    {0x00,0x00,0x00,0x40,0x20,0x10,0x08,0x04,0x08,0x10,0x20,0x40,0x00,0x00,0x00,0x00},
    // 14: full-width tilde
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x72,0x8E,0x00,0x00,0x00,0x00,0x00},
    // 15: full-width at
    {0x00,0x00,0x00,0x38,0x44,0x5A,0xAA,0xAA,0xAA,0xAA,0xB4,0x42,0x44,0x38,0x00,0x00},
    // 16: full-width dollar
    {0x00,0x00,0x08,0x3C,0x4A,0x4A,0x48,0x38,0x0C,0x0A,0x0A,0x4A,0x4A,0x3C,0x08,0x08},
    // 17: full-width hash
    {0x00,0x00,0x24,0x24,0xFE,0x24,0x24,0xFE,0x24,0x24,0x24,0x00,0x00,0x00,0x00,0x00},
    // 18: full-width percent
    {0x00,0x00,0x00,0x62,0x64,0x64,0x68,0x68,0x10,0x16,0x26,0x2A,0x46,0x44,0x00,0x00},
    // 19: full-width ampersand
    {0x00,0x00,0x00,0x1C,0x36,0x22,0x34,0x18,0x3A,0x46,0x42,0x46,0x3C,0x00,0x00,0x00},
    // 20: full-width asterisk
    {0x00,0x00,0x08,0x08,0x3E,0x1C,0x3E,0x08,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    // 21: full-width plus
    {0x00,0x00,0x00,0x00,0x10,0x10,0x10,0xFE,0x10,0x10,0x10,0x00,0x00,0x00,0x00,0x00},
    // 22: full-width double quote
    {0x00,0x00,0x18,0x18,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    // 23: full-width single quote
    {0x00,0x00,0x10,0x10,0x10,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    // 24: left book title mark
    {0x00,0x12,0x14,0x24,0x28,0x48,0x50,0x90,0xA0,0x50,0x50,0x28,0x28,0x24,0x14,0x12},
    // 25: right book title mark
    {0x00,0x48,0x28,0x24,0x14,0x12,0x0A,0x09,0x09,0x0A,0x12,0x14,0x24,0x28,0x48,0x40},
    // 26: left double quote (CJK)
    {0x00,0x00,0x12,0x24,0x4C,0xEE,0xEE,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    // 27: right double quote (CJK)
    {0x00,0x26,0x77,0x77,0x22,0x24,0xC8,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    // 28: left single quote (CJK)
    {0x00,0x00,0x18,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    // 29: right single quote (CJK)
    {0x00,0x00,0x60,0x60,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    // 30: ellipsis
    {0x00,0x00,0x00,0x00,0x00,0x00,0x49,0x49,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    // 31: em dash
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7E,0x7E,0x00,0x00,0x00,0x00,0x00,0x00},
    // 32: RMB yuan
    {0x00,0x00,0x00,0x00,0x22,0x34,0x14,0x18,0x08,0x3C,0x08,0x08,0x08,0x08,0x00,0x00},
};

// ============================================================
// 8x16 digits (0-9)
// ============================================================
static const unsigned char font8x16_digit[10][16] = {
    {0x00,0x00,0x3C,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x18,0x38,0x78,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x7E,0x00,0x00,0x00},
    {0x00,0x00,0x3C,0x66,0x66,0x06,0x06,0x0C,0x18,0x30,0x60,0x40,0x7E,0x00,0x00,0x00},
    {0x00,0x00,0x3C,0x66,0x66,0x06,0x0C,0x18,0x0C,0x06,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x0C,0x1C,0x3C,0x6C,0xCC,0xCC,0xFE,0x0C,0x0C,0x0C,0x1E,0x00,0x00,0x00},
    {0x00,0x00,0x7E,0x60,0x60,0x60,0x7C,0x66,0x06,0x06,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x1C,0x30,0x60,0x60,0x7C,0x66,0x66,0x66,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x7E,0x66,0x66,0x06,0x06,0x0C,0x0C,0x18,0x18,0x18,0x18,0x00,0x00,0x00},
    {0x00,0x00,0x3C,0x66,0x66,0x66,0x66,0x3C,0x66,0x66,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x3C,0x66,0x66,0x66,0x66,0x3E,0x06,0x06,0x06,0x0C,0x38,0x00,0x00,0x00},
};

// ============================================================
// 8x16 uppercase (A-Z)
// ============================================================
static const unsigned char font8x16_upper[26][16] = {
    {0x00,0x00,0x18,0x3C,0x66,0x66,0x66,0x66,0x7E,0x66,0x66,0x66,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x7C,0x66,0x66,0x66,0x66,0x7C,0x66,0x66,0x66,0x66,0x7C,0x00,0x00,0x00},
    {0x00,0x00,0x3C,0x66,0x66,0x60,0x60,0x60,0x60,0x60,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x7C,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x7C,0x00,0x00,0x00},
    {0x00,0x00,0x7E,0x60,0x60,0x60,0x60,0x7C,0x60,0x60,0x60,0x60,0x7E,0x00,0x00,0x00},
    {0x00,0x00,0x7E,0x60,0x60,0x60,0x60,0x7C,0x60,0x60,0x60,0x60,0x60,0x00,0x00,0x00},
    {0x00,0x00,0x3C,0x66,0x66,0x60,0x60,0x6E,0x66,0x66,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x66,0x66,0x66,0x66,0x66,0x7E,0x66,0x66,0x66,0x66,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x3C,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x1E,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x6C,0x38,0x00,0x00,0x00},
    {0x00,0x00,0x66,0x6C,0x6C,0x78,0x78,0x70,0x78,0x78,0x6C,0x6C,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x7E,0x00,0x00,0x00},
    {0x00,0x00,0x66,0x66,0x66,0x76,0x7E,0x6E,0x66,0x66,0x66,0x66,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x66,0x66,0x66,0x66,0x76,0x7E,0x6E,0x66,0x66,0x66,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x3C,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x7C,0x66,0x66,0x66,0x66,0x7C,0x60,0x60,0x60,0x60,0x60,0x00,0x00,0x00},
    {0x00,0x00,0x3C,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x6E,0x6C,0x3E,0x00,0x00,0x00},
    {0x00,0x00,0x7C,0x66,0x66,0x66,0x66,0x7C,0x78,0x6C,0x66,0x66,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x3C,0x66,0x66,0x60,0x30,0x18,0x0C,0x06,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x7E,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x00,0x00,0x00},
    {0x00,0x00,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x3C,0x18,0x18,0x00,0x00,0x00},
    {0x00,0x00,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x6E,0x7E,0x76,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x66,0x66,0x66,0x66,0x3C,0x18,0x3C,0x66,0x66,0x66,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x66,0x66,0x66,0x66,0x3C,0x18,0x18,0x18,0x18,0x18,0x18,0x00,0x00,0x00},
    {0x00,0x00,0x7E,0x06,0x06,0x0C,0x18,0x30,0x60,0x60,0x60,0x60,0x7E,0x00,0x00,0x00},
};

// ============================================================
// 8x16 lowercase (a-z)
// ============================================================
static const unsigned char font8x16_lower[26][16] = {
    {0x00,0x00,0x00,0x00,0x3C,0x66,0x06,0x3E,0x66,0x66,0x66,0x6E,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x60,0x60,0x60,0x7C,0x66,0x66,0x66,0x66,0x66,0x66,0x7C,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x3C,0x66,0x60,0x60,0x60,0x60,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x06,0x06,0x06,0x3E,0x66,0x66,0x66,0x66,0x66,0x66,0x3E,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x3C,0x66,0x66,0x7E,0x60,0x60,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x1C,0x36,0x30,0x30,0x7C,0x30,0x30,0x30,0x30,0x30,0x30,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x3E,0x66,0x66,0x66,0x66,0x3E,0x06,0x06,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x60,0x60,0x60,0x7C,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x18,0x18,0x00,0x38,0x18,0x18,0x18,0x18,0x18,0x18,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x0C,0x0C,0x00,0x1C,0x0C,0x0C,0x0C,0x0C,0x0C,0x6C,0x38,0x00,0x00,0x00},
    {0x00,0x00,0x60,0x60,0x60,0x66,0x6C,0x78,0x70,0x78,0x6C,0x66,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x38,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x6C,0x7E,0x7E,0x6E,0x66,0x66,0x66,0x66,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x7C,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x3C,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x7C,0x66,0x66,0x66,0x66,0x7C,0x60,0x60,0x60,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x3E,0x66,0x66,0x66,0x66,0x3E,0x06,0x06,0x06,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x6E,0x76,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x3C,0x66,0x60,0x38,0x0C,0x06,0x66,0x66,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x30,0x30,0x30,0x7C,0x30,0x30,0x30,0x30,0x30,0x36,0x1C,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x6E,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x66,0x66,0x66,0x66,0x66,0x66,0x3C,0x18,0x18,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x66,0x66,0x66,0x66,0x66,0x6E,0x7E,0x76,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x66,0x66,0x66,0x3C,0x18,0x3C,0x66,0x66,0x66,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x66,0x66,0x66,0x66,0x66,0x3E,0x06,0x06,0x3C,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x7E,0x06,0x06,0x0C,0x18,0x30,0x60,0x60,0x7E,0x00,0x00,0x00},
};

// ============================================================
// Draw functions
// ============================================================

// Draw 8x16 punctuation
inline void drawPunctChar(int x, int y, uint8_t fontIndex, uint16_t color, uint8_t size = 1) {
    uint16_t col = fixColor(color);
    const unsigned char* data = font8x16_punct[fontIndex];
    for (int row = 0; row < 16; row++) {
        for (int col_bit = 0; col_bit < 8; col_bit++) {
            if (data[row] & (1 << (7 - col_bit))) {
                for (int sx = 0; sx < size; sx++) {
                    for (int sy = 0; sy < size; sy++) {
                        tft.drawPixel(x + col_bit * size + sx, y + row * size + sy, col);
                    }
                }
            }
        }
    }
}

// Draw 8x16 digit
inline void cn_drawDigit(int x, int y, uint8_t digit, uint16_t color, uint8_t size = 1) {
    if (digit > 9) return;
    uint16_t col = fixColor(color);
    const unsigned char* data = font8x16_digit[digit];
    for (int row = 0; row < 16; row++) {
        for (int col_bit = 0; col_bit < 8; col_bit++) {
            if (data[row] & (1 << (7 - col_bit))) {
                for (int sx = 0; sx < size; sx++) {
                    for (int sy = 0; sy < size; sy++) {
                        tft.drawPixel(x + col_bit * size + sx, y + row * size + sy, col);
                    }
                }
            }
        }
    }
}

// Draw 8x16 letter
inline void cn_drawChar(int x, int y, char c, uint16_t color, uint8_t size = 1) {
    uint16_t col = fixColor(color);
    const unsigned char* data = NULL;
    int idx = -1;
    
    if (c >= 'A' && c <= 'Z') {
        idx = c - 'A';
        data = font8x16_upper[idx];
    } else if (c >= 'a' && c <= 'z') {
        idx = c - 'a';
        data = font8x16_lower[idx];
    } else {
        screen_draw_char(x, y, c, color, size);
        return;
    }
    if (data == NULL) return;
    
    for (int row = 0; row < 16; row++) {
        for (int col_bit = 0; col_bit < 8; col_bit++) {
            if (data[row] & (1 << (7 - col_bit))) {
                for (int sx = 0; sx < size; sx++) {
                    for (int sy = 0; sy < size; sy++) {
                        tft.drawPixel(x + col_bit * size + sx, y + row * size + sy, col);
                    }
                }
            }
        }
    }
}

// Check if char is ASCII punctuation
inline bool isEnglishPunct(char c) {
    return (c == ':' || c == '/' || c == '-' || c == '.' || 
            c == ',' || c == '!' || c == '?' || c == ';' ||
            c == '(' || c == ')' || c == '[' || c == ']' ||
            c == '=' || c == '+' || c == '*' || c == '#' ||
            c == '@' || c == '$' || c == '%' || c == '&' ||
            c == '~' || c == '^' || c == '_' || c == '|' ||
            c == '\\' || c == '\"' || c == '\'' || c == '<' ||
            c == '>' || c == '`');
}

// ASCII punct -> full-width punct index
inline int englishPunctToFullIndex(char c) {
    switch(c) {
        case ',': return 0;
        case '.': return 1;
        case '!': return 2;
        case '?': return 3;
        case ':': return 4;
        case ';': return 5;
        case '(': return 6;
        case ')': return 7;
        case '[': return 8;
        case ']': return 9;
        case '-': return 10;
        case '=': return 11;
        case '<': return 12;
        case '>': return 13;
        case '~': return 14;
        case '@': return 15;
        case '$': return 16;
        case '#': return 17;
        case '%': return 18;
        case '&': return 19;
        case '*': return 20;
        case '+': return 21;
        case '\"': return 22;
        case '\'': return 23;
        // fallback mapping
        case '/': return 18;
        case '_': return 10;
        case '|': return 15;
        case '\\': return 18;
        case '^': return 14;
        case '`': return 22;
        default: return -1;
    }
}

// Check if UTF-8 3-byte sequence is a CJK punctuation
inline bool isChinesePunct(const char* p) {
    if (!p || strlen(p) < 3) return false;
    unsigned char b1 = (unsigned char)p[0];
    unsigned char b2 = (unsigned char)p[1];
    unsigned char b3 = (unsigned char)p[2];
    
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x8C) return true; // ，
    if (b1 == 0xE3 && b2 == 0x80 && b3 == 0x82) return true; // 。
    if (b1 == 0xE3 && b2 == 0x80 && b3 == 0x81) return true; // 、
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x81) return true; // ！
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x9F) return true; // ？
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x9A) return true; // ：
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x9B) return true; // ；
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x88) return true; // （
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x89) return true; // ）
    if (b1 == 0xE3 && b2 == 0x80 && b3 == 0x90) return true; // 【
    if (b1 == 0xE3 && b2 == 0x80 && b3 == 0x91) return true; // 】
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x8D) return true; // －
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x9D) return true; // ＝
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x9C) return true; // ＜
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x9E) return true; // ＞
    if (b1 == 0xEF && b2 == 0xBD && b3 == 0x9E) return true; // ～
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x80) return true; // ＠
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x84) return true; // ＄
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x83) return true; // ＃
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x85) return true; // ％
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x86) return true; // ＆
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x8A) return true; // ＊
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x8B) return true; // ＋
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x82) return true; // ＂
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x87) return true; // ＇
    if (b1 == 0xE3 && b2 == 0x80 && b3 == 0x8A) return true; // 《
    if (b1 == 0xE3 && b2 == 0x80 && b3 == 0x8B) return true; // 》
    if (b1 == 0xE2 && b2 == 0x80 && b3 == 0x9C) return true; // “
    if (b1 == 0xE2 && b2 == 0x80 && b3 == 0x9D) return true; // ”
    if (b1 == 0xE2 && b2 == 0x80 && b3 == 0x98) return true; // ‘
    if (b1 == 0xE2 && b2 == 0x80 && b3 == 0x99) return true; // ’
    if (b1 == 0xE2 && b2 == 0x80 && b3 == 0xA6) return true; // …
    if (b1 == 0xE2 && b2 == 0x80 && b3 == 0x94) return true; // —
    if (b1 == 0xEF && b2 == 0xBF && b3 == 0xA5) return true; // ￥
    return false;
}

// CJK punct -> font8x16_punct index
inline int chinesePunctToIndex(const char* p) {
    if (!p || strlen(p) < 3) return -1;
    unsigned char b1 = (unsigned char)p[0];
    unsigned char b2 = (unsigned char)p[1];
    unsigned char b3 = (unsigned char)p[2];
    
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x8C) return 0; // ，
    if (b1 == 0xE3 && b2 == 0x80 && b3 == 0x82) return 1; // 。
    if (b1 == 0xE3 && b2 == 0x80 && b3 == 0x81) return 0; // 、 -> comma
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x81) return 2; // ！
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x9F) return 3; // ？
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x9A) return 4; // ：
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x9B) return 5; // ；
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x88) return 6; // （
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x89) return 7; // ）
    if (b1 == 0xE3 && b2 == 0x80 && b3 == 0x90) return 8; // 【
    if (b1 == 0xE3 && b2 == 0x80 && b3 == 0x91) return 9; // 】
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x8D) return 10; // －
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x9D) return 11; // ＝
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x9C) return 12; // ＜
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x9E) return 13; // ＞
    if (b1 == 0xEF && b2 == 0xBD && b3 == 0x9E) return 14; // ～
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x80) return 15; // ＠
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x84) return 16; // ＄
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x83) return 17; // ＃
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x85) return 18; // ％
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x86) return 19; // ＆
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x8A) return 20; // ＊
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x8B) return 21; // ＋
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x82) return 22; // ＂
    if (b1 == 0xEF && b2 == 0xBC && b3 == 0x87) return 23; // ＇
    if (b1 == 0xE3 && b2 == 0x80 && b3 == 0x8A) return 24; // 《
    if (b1 == 0xE3 && b2 == 0x80 && b3 == 0x8B) return 25; // 》
    if (b1 == 0xE2 && b2 == 0x80 && b3 == 0x9C) return 26; // “
    if (b1 == 0xE2 && b2 == 0x80 && b3 == 0x9D) return 27; // ”
    if (b1 == 0xE2 && b2 == 0x80 && b3 == 0x98) return 28; // ‘
    if (b1 == 0xE2 && b2 == 0x80 && b3 == 0x99) return 29; // ’
    if (b1 == 0xE2 && b2 == 0x80 && b3 == 0xA6) return 30; // …
    if (b1 == 0xE2 && b2 == 0x80 && b3 == 0x94) return 31; // —
    if (b1 == 0xEF && b2 == 0xBF && b3 == 0xA5) return 32; // ￥
    return -1;
}

// Draw mixed ASCII / CJK text (single entry point)
inline void drawMixedText(int x, int y, const char* str, uint16_t color, uint8_t size = 1) {
    int posX = x;
    const char* p = str;
    int charWidth = 8 * size;
    int chineseWidth = 16 * size;
    int punctCount = sizeof(font8x16_punct) / sizeof(font8x16_punct[0]);
    
    while (*p) {
        unsigned char c = (unsigned char)*p;
        
        // digits
        if (c >= '0' && c <= '9') {
            cn_drawDigit(posX, y, c - '0', color, size);
            posX += charWidth;
            p++;
        } 
        // letters
        else if ((c >= 'A' && c <= 'Z') || (c >= 'a' && c <= 'z')) {
            cn_drawChar(posX, y, c, color, size);
            posX += charWidth;
            p++;
        } 
        // ASCII punctuation
        else if (isEnglishPunct(c)) {
            int idx = englishPunctToFullIndex(c);
            if (idx >= 0 && idx < punctCount) {
                drawPunctChar(posX, y, idx, color, size);
                posX += charWidth;
            } else {
                char buf[2] = {c, 0};
                drawtext(posX, y, buf, color, size);
                posX += 6 * size;
            }
            p++;
        } 
        // space
        else if (c == ' ') {
            posX += charWidth;
            p++;
        } 
        // other ASCII
        else if (c < 0x80) {
            char buf[2] = {c, 0};
            drawtext(posX, y, buf, color, size);
            posX += 6 * size;
            p++;
        } 
        // UTF-8 3-byte (CJK char or CJK punct)
        else if (c >= 0xE0 && c <= 0xEF) {
            if (strlen(p) >= 3) {
                if (isChinesePunct(p)) {
                    int idx = chinesePunctToIndex(p);
                    if (idx >= 0 && idx < punctCount) {
                        drawPunctChar(posX, y, idx, color, size);
                        posX += charWidth;
                    } else {
                        char buf[4] = {p[0], p[1], p[2], 0};
                        fontManager.drawString(posX, y, buf, color, size);
                        posX += chineseWidth;
                    }
                    p += 3;
                } else {
                    char chineseBuf[4] = {p[0], p[1], p[2], 0};
                    fontManager.drawString(posX, y, chineseBuf, color, size);
                    posX += chineseWidth;
                    p += 3;
                }
            } else {
                break;
            }
        } 
        else {
            p++;
        }
    }
}

// ============================================================
// Internal font init
// ============================================================
inline void initInternalFont() {
    fontManager.init((const InternalChar*)CHINESE_TABLE, CHINESE_COUNT);
}

#endif